Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: BASIC CORSET D
Time: 2020-09-14T13:54:04
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 101547_Default (2)
In: Default Storey
Name
101547_Default | PSet_Mass_Property - Mass Measure: 25.9148; Area Measure: 2.38127 m2; Volume Measure: 0.00336485 m3
101547_Default

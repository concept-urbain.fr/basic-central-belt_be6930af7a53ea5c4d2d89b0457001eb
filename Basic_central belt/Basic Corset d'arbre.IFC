Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Basic Corset d
Time: 2020-07-03T11:58:52
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: INS-TAFF-M8-1.5-5-A2_Default (4)
In: Default Storey
Material: Inox A2-70

# IfcBuildingElementProxy: BASI-CORS-MUL-001-01_Default (2)
In: Default Storey
Name
BASI-CORS-MUL-001-01_Default | PSet_Mass_Property - Mass Measure: 45.0754; Area Measure: 3.531; Volume Measure: 0.00574172
BASI-CORS-MUL-001-01_Default

# IfcBuildingElementProxy: INS-TAFF-M8-1.5-5-A2_Default (2)
In: Default Storey
Material: Inox A2-70
